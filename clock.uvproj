# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group source code
    ./: STARTUP.A51
    ./code/: LCD1602.c DS1302.c DS18B20.c EEPROM.c clock.c
  group header
    ./code/: LCD1602.h pins.h DS1302.h DS18B20.h EEPROM.h
